Commit message: tracing the 25% of the circular contour

File: models/force_control/my_kuka.urdf (robot description, URDF)
Before this commit: robot lbr_iiwa, 10 links, 9 joints
Links:
- link tool: geometry collision cylinder length=0.2 radius=0.01; visual cylinder length=0.17 radius=0.01
